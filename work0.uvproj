# Keil uVision project work0.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: work0 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group
    ./: Main.c LCD1602.c GSM.c DHT11.c
  group Include Group
    ./: Config.h LCD1602.h DHT11.h GSM.h
